<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project_2.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Project_2.hex</name>
      <member>
        <project>Project_2</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


